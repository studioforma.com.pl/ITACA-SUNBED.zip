Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [TrimBim], ExchangeRequirement [Any]
File name: Itaca-Sunbed - ver4.ifc
Time: 2025-11-14T14:34:29
Author: Utente
Organization: Trimble
Written by: Trimble SketchUp
Made in: Trimble SketchUp
Authorization: IFC4 model

# IfcBuildingElementProxy (15)
Name
 | Itaca-Sunbed_3 - ObjectType: SketchupGroup
 | Itaca-Sunbed_4 - ObjectType: SketchupGroup
 | Itaca-Sunbed_2 - ObjectType: SketchupGroup
 | Itaca-Sunbed_0 - ObjectType: SketchupGroup
 | Itaca-Sunbed_1 - ObjectType: SketchupGroup
 | Itaca-Sunbed_5 - ObjectType: SketchupGroup
 | Itaca-Sunbed_6 - ObjectType: SketchupGroup
 | Itaca-Sunbed_7 - ObjectType: SketchupGroup
 | Itaca-Sunbed_8 - ObjectType: SketchupGroup
 | Itaca-Sunbed_9 - ObjectType: SketchupGroup
 | Itaca-Sunbed_10 - ObjectType: SketchupGroup
 | Itaca-Sunbed_11 - ObjectType: SketchupGroup
 | Itaca-Sunbed_12 - ObjectType: SketchupGroup
 | Itaca-Sunbed_13 - ObjectType: SketchupGroup
 | Itaca-Sunbed_14 - ObjectType: SketchupGroup
